# IAR project M0G3507_Project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  ILINK.IlinkOutputFile: M0G3507_Project.out
  group (top)
    ./: M0G3507_Project.ipcf SysConfig_Generated_Files.ipcf
