# Keil uVision project empty_LP_MSPM0G3507_nortos_keil.uvprojx, settings and files
target M0G3507_Project (6240000::V6.24::ARMCLANG)
  device: MSPM0G3507 Texas Instruments
  pack: TexasInstruments.MSPM0G1X0X_G3X0X_DFP.1.3.1
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20100000,0x00008000) IROM(0x00000000,0x00020000) IROM2(0x00400000,0x00020000) XRAM(0x20200000,0x00008000) XRAM2(0x20300000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: M0G3507_Project +hex
  BeforeMake: cmd.exe /C "$P../../tools/keil/syscfg.bat '$P' empty.syscfg"
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0G3507__
  c include: ..;..\..\source\third_party\CMSIS\Core\Include;..\..\source;..\User;..\User\App;..\User\Driver
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x400000 size 0x20000
  memory RVCT6: ROM 0x20200000 size 0x8000
  memory RVCT7: ROM 0x20300000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20100000 size 0x8000
  scatter file: ./mspm0g3507.sct
  link misc: ../../source/ti/driverlib/lib/keil/m0p/mspm0g1x0x_g3x0x/driverlib.a
  group Source
    ../: empty.c empty.syscfg ti_msp_dl_config.h ti_msp_dl_config.c
    ./: startup_mspm0g350x_uvision.s
  group User
    ../User/: scheduler.c scheduler.h
  group User/App
    ../User/App/: led_app.c led_app.h uart_app.c uart_app.h gyro_protocol.c gyro_protocol.h gyro_app.c gyro_app.h motor_protocol.c motor_protocol.h motor_app.c motor_app.h line_track_app.c line_track_app.h oled_app.c oled_app.h key_app.c key_app.h
  group User/Driver
    ../User/Driver/: led_driver.c led_driver.h uart_driver.c uart_driver.h gray_sensor_driver.c gray_sensor_driver.h oled_driver.c oled_driver.h key_driver.c key_driver.h
